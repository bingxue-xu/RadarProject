options:
  parameters:
    author: Group7_2025/2026
    description: B205mini
    generate_options: qt_gui
    id: SFCW_radar_SDR_part2
    output_language: python
    title: SFCW_radar_SDR_part2
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 5.8e9
  states: {}
- name: number_of_steps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: step_period_ms
  id: variable
  parameters:
    value: '200'
  states: {}
- name: tx_ampl
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: tx_ampl
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("tick")
    period: step_period_ms
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: cw_re.wav
    format: FORMAT_WAV
    samp_rate: int(sample_rate)
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: cw_im.wav
    format: FORMAT_WAV
    samp_rate: int(sample_rate)
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          Message-based block that cycles USRP frequency between:
          fc, fc+1*df, ..., fc+Nf*df
          each time a message is received.
          """

          def __init__(self, fc=5.8e9, number_of_steps=2):
              gr.basic_block.__init__(
                  self,
                  name=f'Freq Step Command Block number_of_steps steps',
                  in_sig=None,
                  out_sig=None
              )
              self.fc = fc
              self.num_steps = number_of_steps
              self.step = 50e6
              self.current_step = 1

              # Register message ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))

              # Assign handler for incoming messages
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              """
              Cycle through frequency steps:
              fc, fc+1*df, ..., fc+Nf*df, then wrap back to fc.
              """

              # Compute frequency for current step
              freq = self.fc + self.current_step * self.step
              #print(self.fc)
              #print(self.num_steps)

              # Build PMT dictionary to send to UHD:USRP Sink
              cmd = pmt.make_dict()
              cmd = pmt.dict_add(cmd, pmt.intern("freq"), pmt.from_double(freq))

              # Publish command
              self.message_port_pub(pmt.intern("out"), cmd)

              # Update step (wrap around after last one)
              self.current_step = (self.current_step + 1) % self.num_steps
    fc: fc
    number_of_steps: number_of_steps
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Steps Control - SFCW
  states: {}
- name: note_0_0_2
  id: note
  parameters:
    note: CW Mode
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate*2.5
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: tx_gain
    samp_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: rx_gain
    samp_rate: sample_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0_1, in]
- [epy_block_0_1, out, uhd_usrp_sink_0, command]
- [epy_block_0_1, out, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
