options:
  parameters:
    author: Group7_2025/2026
    description: B205mini, fc=5.8 GHz, f_if=4 kHz, fs=250 kS/s, decim=25, fs_out=10 kS/s
    generate_options: qt_gui
    id: CW_radar_SDR_part2
    output_language: python
    title: CW_radar_SDR_part2
  states: {}

blocks:
- name: f_if
  id: variable
  parameters:
    value: 4e3
  states: {}
- name: fc
  id: variable
  parameters:
    value: 5.8e9
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: tx_ampl
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: tx_ampl
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: tx_ampl
    freq: f_if
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: cw_re.wav
    format: FORMAT_WAV
    samp_rate: int(sample_rate)
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: cw_im.wav
    format: FORMAT_WAV
    samp_rate: int(sample_rate)
  states: {}
- name: blocks_wavfile_sink_0_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: low_if_cw_im.wav
    format: FORMAT_WAV
    samp_rate: int(sample_rate)
  states: {state: disabled}
- name: blocks_wavfile_sink_0_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: low_if_cw_re.wav
    format: FORMAT_WAV
    samp_rate: int(sample_rate)
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: filter_fft_low_pass_filter_1
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: note_0_0
  id: note
  parameters:
    note: CW Mode
  states: {state: disabled}
- name: note_0_0_0
  id: note
  parameters:
    note: Low-IF CW Mode
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: tx_gain
    samp_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: tx_gain
    samp_rate: sample_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: rx_gain
    samp_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: rx_gain
    samp_rate: sample_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_wavfile_sink_0_1, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_wavfile_sink_0_0_0, '0']
- [blocks_complex_to_float_0_0, '1', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', filter_fft_low_pass_filter_1, '0']
- [blocks_multiply_xx_0, '0', filter_fft_low_pass_filter_1, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [dc_blocker_xx_0, '0', blocks_multiply_xx_0, '1']
- [filter_fft_low_pass_filter_1, '0', blocks_complex_to_float_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
